# Add Docker and Go
IMAGE_INSTALL_append = " \
    tensorflow \
"
